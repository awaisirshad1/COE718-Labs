# Keil uVision project usbaudio.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usbaudio +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\common\inc;.\common\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\DMA.sct
  group Source Files
    ./: usbuser.c usbcore.c usbdesc.c usbhw.c adcuser.c main.c
  group Startup Files
    ./: system_LPC17xx.c core_cm3.c startup_LPC17xx.s
  group Peripheral
    ./: Font_6x8_h.h Font_16x24_h.h GLCD.h GLCD_SPI_LPC1700.c KBD.c KBD.h LED.c LED.h
  group Main
    ./: gallery.c gallery.h game.c game.h IRQ.c mainMenu.c mainMenu.h osObjects.h Thread.c
software components: CMSIS:CORE 5.4.0
